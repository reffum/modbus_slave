# Keil uVision project comm_test.uvproj, settings and files
target Debug (ARM-ADS)
  device: STM32F405RG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: comm_test
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\src;..\src\periph;..\lib\std_periph\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group periph
    ../src/periph/: startup_stm32f4xx.s system_stm32f4xx.c gpio.c Serial.c timer.c
  group src
    ../src/: main.c
  group std_periph
    ../lib/std_periph/src/: stm32f4xx_gpio.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_rcc.c
target Release (ARM-ADS)
  device: STM32F405RG STMicroelectronics
  cpu: as above
  output: comm_test
  c flags: Optim=1
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
